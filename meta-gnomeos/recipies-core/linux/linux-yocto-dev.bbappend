FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://kvm.cfg file://uinput.cfg file://drm.cfg file://9p.cfg"
PRINC = "3"
